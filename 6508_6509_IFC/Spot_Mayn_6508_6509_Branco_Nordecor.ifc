Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-12-08T14:09:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Dec 08 14:09:40 2024 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\eab0f5a2-2687-4359-9e40-68844d4d8e3c\201e89e3-02cc-4263-85e0-5cad9a640c66\ifc * Database version: 5507 * Database creation date: Sun Dec 08 14:09:39 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Dec 08 14:09:39 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Dec 08 14:09:39 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcDistributionPort, Port_329964
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: 6508 - Branco, Spot_Mayn_6508_6509_Nordecor_IFC:6508 - Branco:329964
In: Nível 1
Type - Material: Metal - Alumínio, Plástico - Acrílico, LED, Metal - Alumínio extrudado - Branco
Type - Cotas - Altura da luminária: 80 mm; Diâmetro da luminária: 65 mm; Incl.: 0 deg; Inclinação: 0 deg
Type - Dados - Data da atualização: 07/12/2024; Versão: 1
Type - Dados de identidade - Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: contato@nordecor.com.br; Descrição: Spot de embutir com acabamento branco LED 7W, 2700K 24º; Desenvolvedor: Check BIM; Fabricante: Nordecor; Fixação: Molas; Garantia: 2 anos; Grau de proteção: IP20; Localizção: Camboriú-SC / Brasil; Modelo: 6508; Nome do tipo: 6508 - Branco; Número OmniClass: 23.80.70.11.14.21; Tipo de imagem: Imagem raster: 6508.png; Título OmniClass: Spots and Tracklight Specialties; URL: https://nordecor.com.br; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/spot-led-de-embutir-mayn-7w-2-700k-irc97/
Type - Elétrico - Comentários de voltagem: 100-240V; Fator de potência - Luminária: 0.5; Lâmpada: LED
Type - Elétrico - Cargas - Carga aparente - Luminária: 0 W
Type - Engenharia elétrica - Voltagem - Luminária: 0 V
Type - Estrutural - Peso: 0,167kg
Type - Fotométricos - Fluxo luminoso: 560 lm; Grau de abertura: 24 deg; IRC (R9): >93; IRC (RA): >97; Potência: 7 W; SDMC: <5; Temperatura de cor: 2700 K; UGR: <16
Type - Gráficos - Simbologia: Imagem raster: 6508 2D.png
Type - Materiais e acabamentos - Luminária: Metal - Alumínio extrudado - Branco; Nicho: Metal - Alumínio; Refletor: Metal - Alumínio
Type - Outros - Categoria: Luminárias; Branco: yes; Nome da família: Spot_Mayn_6508_6509_Nordecor_IFC; Preto: no
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes; Fonte luminosa: yes
Cotas - Área: 0.0154759 m2; Volume: 0.000123821 m3
Dados de identidade - Marca: 1
Elétrico - Circuitos - Dados elétricos: 0 V/1-0 VA
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Spot_Mayn_6508_6509_Nordecor_IFC: 6508 - Branco; Família e tipo: Spot_Mayn_6508_6509_Nordecor_IFC: 6508 - Branco; ID de tipo: Spot_Mayn_6508_6509_Nordecor_IFC: 6508 - Branco; Tipo: Spot_Mayn_6508_6509_Nordecor_IFC: 6508 - Branco
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
